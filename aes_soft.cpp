// aes_soft.cpp -- siehe aes_soft.h. Kanonischer AES (FIPS-197), abgeleitet aus der gemeinfreien
// tiny-AES-Referenz; nur Software (kein Hardware-AES, keine DMA, kein Heap).
#include "aes_soft.h"
#include <string.h>

static const uint8_t kSbox[256] = {
0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16 };

static const uint8_t kInvSbox[256] = {
0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d };

static const uint8_t kRcon[11] = { 0x8d,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36 };

static inline uint8_t xtime(uint8_t x) { return (uint8_t)((x << 1) ^ ((x >> 7) * 0x1b)); }
static uint8_t mul(uint8_t x, uint8_t y) {
    uint8_t r = 0;
    for (int i = 0; i < 8; i++) { if (y & 1) r ^= x; uint8_t hi = x & 0x80; x <<= 1; if (hi) x ^= 0x1b; y >>= 1; }
    return r;
}

// Rundenschluessel: Nk = klen/4 (4/6/8), Nr = Nk+6 (10/12/14). RoundKey = 16*(Nr+1) Byte <= 240.
static void keyExpansion(const uint8_t* key, size_t klen, uint8_t* rk, int* Nr) {
    int Nk = (int)(klen / 4); *Nr = Nk + 6;
    int total = 4 * (*Nr + 1);   // Woerter
    memcpy(rk, key, klen);
    uint8_t t[4];
    for (int i = Nk; i < total; i++) {
        memcpy(t, rk + 4 * (i - 1), 4);
        if (i % Nk == 0) {
            uint8_t tmp = t[0]; t[0] = kSbox[t[1]] ^ kRcon[i / Nk]; t[1] = kSbox[t[2]]; t[2] = kSbox[t[3]]; t[3] = kSbox[tmp];
        } else if (Nk > 6 && i % Nk == 4) {
            for (int j = 0; j < 4; j++) t[j] = kSbox[t[j]];
        }
        for (int j = 0; j < 4; j++) rk[4 * i + j] = rk[4 * (i - Nk) + j] ^ t[j];
    }
}

static void addRoundKey(uint8_t* s, const uint8_t* rk) { for (int i = 0; i < 16; i++) s[i] ^= rk[i]; }

static void encBlock(uint8_t* s, const uint8_t* rk, int Nr) {
    addRoundKey(s, rk);
    for (int round = 1; round <= Nr; round++) {
        for (int i = 0; i < 16; i++) s[i] = kSbox[s[i]];                 // SubBytes
        uint8_t t;                                                       // ShiftRows
        t = s[1];  s[1]=s[5];  s[5]=s[9];  s[9]=s[13];  s[13]=t;
        t = s[2];  s[2]=s[10]; s[10]=t; t=s[6]; s[6]=s[14]; s[14]=t;
        t = s[15]; s[15]=s[11];s[11]=s[7]; s[7]=s[3]; s[3]=t;
        if (round != Nr) {                                               // MixColumns
            for (int c = 0; c < 4; c++) {
                uint8_t* col = s + 4 * c;
                uint8_t a0=col[0],a1=col[1],a2=col[2],a3=col[3];
                col[0]=(uint8_t)(xtime(a0)^(xtime(a1)^a1)^a2^a3);
                col[1]=(uint8_t)(a0^xtime(a1)^(xtime(a2)^a2)^a3);
                col[2]=(uint8_t)(a0^a1^xtime(a2)^(xtime(a3)^a3));
                col[3]=(uint8_t)((xtime(a0)^a0)^a1^a2^xtime(a3));
            }
        }
        addRoundKey(s, rk + 16 * round);
    }
}

static void decBlock(uint8_t* s, const uint8_t* rk, int Nr) {
    addRoundKey(s, rk + 16 * Nr);
    for (int round = Nr - 1; round >= 0; round--) {
        uint8_t t;                                                       // InvShiftRows
        t = s[13]; s[13]=s[9]; s[9]=s[5]; s[5]=s[1]; s[1]=t;
        t = s[2];  s[2]=s[10]; s[10]=t; t=s[6]; s[6]=s[14]; s[14]=t;
        t = s[3];  s[3]=s[7];  s[7]=s[11]; s[11]=s[15]; s[15]=t;
        for (int i = 0; i < 16; i++) s[i] = kInvSbox[s[i]];              // InvSubBytes
        addRoundKey(s, rk + 16 * round);
        if (round != 0) {                                               // InvMixColumns
            for (int c = 0; c < 4; c++) {
                uint8_t* col = s + 4 * c;
                uint8_t a0=col[0],a1=col[1],a2=col[2],a3=col[3];
                col[0]=(uint8_t)(mul(a0,14)^mul(a1,11)^mul(a2,13)^mul(a3,9));
                col[1]=(uint8_t)(mul(a0,9)^mul(a1,14)^mul(a2,11)^mul(a3,13));
                col[2]=(uint8_t)(mul(a0,13)^mul(a1,9)^mul(a2,14)^mul(a3,11));
                col[3]=(uint8_t)(mul(a0,11)^mul(a1,13)^mul(a2,9)^mul(a3,14));
            }
        }
    }
}

int aes_soft_cbc(int enc, const uint8_t* key, size_t klen, const uint8_t iv[16],
                 const uint8_t* in, size_t len, uint8_t* out) {
    if ((klen != 16 && klen != 24 && klen != 32) || (len % 16) != 0 || !key || !iv || !in || !out) return -1;
    uint8_t rk[240]; int Nr;
    keyExpansion(key, klen, rk, &Nr);
    uint8_t chain[16]; memcpy(chain, iv, 16);
    uint8_t blk[16];
    for (size_t off = 0; off < len; off += 16) {
        if (enc) {
            for (int i = 0; i < 16; i++) blk[i] = in[off + i] ^ chain[i];
            encBlock(blk, rk, Nr);
            memcpy(out + off, blk, 16);
            memcpy(chain, blk, 16);
        } else {
            uint8_t cin[16]; memcpy(cin, in + off, 16);   // in==out sicher
            memcpy(blk, cin, 16);
            decBlock(blk, rk, Nr);
            for (int i = 0; i < 16; i++) out[off + i] = blk[i] ^ chain[i];
            memcpy(chain, cin, 16);
        }
    }
    return 0;
}
